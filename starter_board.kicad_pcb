# Repository syedshazli/pcb-2

File README.md:

## Starter Board

This folder contains the Track 1 starter board files. You'll want to open up the `.kicad_pro` file in KiCad. This is the root project file that will allow you to navigate between your board and schematic views.

Steps to Pull/Add
1. Git Status
        If someone else is committed before you 
        (has code before you put it in)
        "Your branch is behind" --> Git Pull
2. Put changes into repository so Syed can View
        Use: Git add -A
3. Put a message behind why you're adding changes to code
        Use: Git commit -m "message"
4. Use: Git push; to push changes to code to repository for Syed to see

d

## KiCad design starter_board.kicad_pcb

Parts:
C1: 100uF; CP_Elec_5x5.3
C2, C6: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: TX; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: RX; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
J1, J2: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J3: ICSP; PinHeader_2x03_P2.54mm_Vertical
J4: USB_B_Micro; USB_Micro-B_GCT_USB3076-30-A
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R1, R2: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 22; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 470; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SW_SPST_PTS647_Sx38
U1: ATmega32U4-A; TQFP-44_10x10mm_P0.8mm
Y1: 16MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm

Connections:
+5V: C1.1, C2.1, D3.4 (VDD), D4.4 (VDD), D5.4 (VDD), D6.4 (VDD), D7.4 (VDD), D8.4 (VDD), D9.4 (VDD), D10.4 (VDD), D11.4 (VDD), D12.4 (VDD), D13.4 (VDD), D14.4 (VDD), D15.4 (VDD), D16.4 (VDD), D17.4 (VDD), D18.4 (VDD), D19.4 (VDD), D20.4 (VDD), D21.4 (VDD), D22.4 (VDD), D23.4 (VDD), J1.1, J3.2, JP1.2 (B), R1.2, R2.2, R5.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
/A0: J1.9, U1.36 (PF7)
/A1: J1.8, U1.37 (PF6)
/A2: J1.7, U1.38 (PF5)
/A3: J1.6, U1.39 (PF4)
/A4: J1.5, U1.40 (PF1)
/A5: J1.4, U1.41 (PF0)
/AREF: C5.1, J1.2, U1.42 (AREF)
/D0: J2.5, U1.20 (PD2)
/D1: J2.4, U1.21 (PD3)
/D2: J2.3, U1.19 (PD1)
/D3: J2.2, U1.18 (PD0)
/D4: J2.7, U1.25 (PD4)
/D7: SW1.2, U1.1 (PE6)
/D8: J2.8, U1.28 (PB4)
/D9: J2.9, U1.29 (PB5)
/D9_DOUT: D9.1 (DOUT), D10.3 (DIN)
/D10: J2.10, U1.30 (PB6)
/D11: J2.6, U1.12 (PB7)
/D13: J1.10, U1.32 (PC7)
/D16_DOUT: D16.1 (DOUT), D17.3 (DIN)
/D23_DOUT: D23.1 (DOUT)
/D+: R3.1, U1.4 (D+)
/D-: R4.1, U1.3 (D-)
/LED_DIN: R6.1, U1.31 (PC6)
/MISO: J3.1, U1.11 (PB3)
/MOSI: J3.4, U1.10 (PB2)
/RESET: J3.5, R5.2, U1.13 (~RESET)
/RXLED: D2.1 (K), U1.8 (PB0)
/SCK: J3.3, U1.9 (PB1)
/TXLED: D1.1 (K), U1.22 (PD5)
/U_D+: J4.3 (D+), R3.2
/U_D-: J4.2 (D-), R4.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D3.2 (VSS), D4.2 (VSS), D5.2 (VSS), D6.2 (VSS), D7.2 (VSS), D8.2 (VSS), D9.2 (VSS), D10.2 (VSS), D11.2 (VSS), D12.2 (VSS), D13.2 (VSS), D14.2 (VSS), D15.2 (VSS), D16.2 (VSS), D17.2 (VSS), D18.2 (VSS), D19.2 (VSS), D20.2 (VSS), D21.2 (VSS), D22.2 (VSS), D23.2 (VSS), J1.3, J2.1, J3.6, J4.5 (GND), SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.33 (~HWB/PE2), U1.35 (GND), U1.43 (GND)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.3 (DIN), R6.2
unnamed: D3.1 (DOUT), D4.3 (DIN)
unnamed: D4.1 (DOUT), D5.3 (DIN)
unnamed: D5.1 (DOUT), D6.3 (DIN)
unnamed: D6.1 (DOUT), D7.3 (DIN)
unnamed: D7.1 (DOUT), D8.3 (DIN)
unnamed: D8.1 (DOUT), D9.3 (DIN)
unnamed: D10.1 (DOUT), D11.3 (DIN)
unnamed: D11.1 (DOUT), D12.3 (DIN)
unnamed: D12.1 (DOUT), D13.3 (DIN)
unnamed: D13.1 (DOUT), D14.3 (DIN)
unnamed: D14.1 (DOUT), D15.3 (DIN)
unnamed: D15.1 (DOUT), D16.3 (DIN)
unnamed: D17.1 (DOUT), D18.3 (DIN)
unnamed: D18.1 (DOUT), D19.3 (DIN)
unnamed: D19.1 (DOUT), D20.3 (DIN)
unnamed: D20.1 (DOUT), D21.3 (DIN)
unnamed: D21.1 (DOUT), D22.3 (DIN)
unnamed: D22.1 (DOUT), D23.3 (DIN)
unnamed: J4.1 (VBUS), JP1.1 (A)
unnamed: C6.1, U1.6 (UCAP)
unnamed: C3.1, U1.17 (XTAL1), Y1.1
unnamed: C4.1, U1.16 (XTAL2), Y1.2

Notes on the sheet:
MOSI
Push Button
D2/SDA
LEDS
D11
D3/SCL
USB
DECOUPLING
D1(TX)
D13
WS2812-B no longer require decoupling caps!
Author: Daniel Gorbunov
MISO
D10
POWER + MCU
TX/RX LEDS
ICSP
SCK
D12
D0(RX)

Board: 2 copper layers, 102.0 x 40.0 mm, 43 parts (0 on the bottom side), 58 nets.

## Commit log

2024-10-20 change ReadMe
2024-10-20 Add files via upload
    Edit #1
